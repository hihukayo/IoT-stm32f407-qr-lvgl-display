# Keil uVision project QR_LVGL_F407.uvprojx, settings and files
target QR_LVGL_F407 (6070000::V6.7::ARMCLANG)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x8000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QR_LVGL_F407 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Middlewares\lvgl;..\Middlewares\qrcodegen
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Core/Src/: app.c bmp_stream.c lcd_st7789.c lv_port_disp.c lvgl_ui.c main.c platform_compat.c qr_bitmap.c qr_service.c storage.c stm32f4xx_hal_msp.c stm32f4xx_it.c uart_protocol.c
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group HAL Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group QR Code
    ../Middlewares/qrcodegen/: qrcodegen.c
  group LVGL
    ../Middlewares/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/lvgl/src/debugging/monkey/: lv_monkey.c
    ../Middlewares/lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../Middlewares/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../Middlewares/lvgl/src/debugging/test/: lv_test_display.c lv_test_display_egl.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/lvgl/src/display/: lv_display.c
    ../Middlewares/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../Middlewares/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../Middlewares/lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_blur.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../Middlewares/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_cache.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../Middlewares/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Middlewares/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/lvgl/src/draw/sifli/epic/: lv_draw_buf_sifli_epic.c lv_draw_sifli_epic.c lv_draw_sifli_epic_border.c lv_draw_sifli_epic_fill.c lv_draw_sifli_epic_img.c lv_draw_sifli_epic_label.c lv_draw_sifli_epic_layer.c lv_sifli_epic_cfg.c lv_sifli_epic_osa.c lv_sifli_epic_utils.c
    ../Middlewares/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../Middlewares/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../Middlewares/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middlewares/lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../Middlewares/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Middlewares/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../Middlewares/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../Middlewares/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../Middlewares/lvgl/src/drivers/display/mipi/: lv_ili9341.c lv_lcd_generic_mipi.c lv_nv3007.c lv_st7735.c lv_st7789.c lv_st7796.c
    ../Middlewares/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../Middlewares/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../Middlewares/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../Middlewares/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../Middlewares/lvgl/src/drivers/evdev/: lv_evdev.c
    ../Middlewares/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../Middlewares/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../Middlewares/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../Middlewares/lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../Middlewares/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_pbuffer.c lv_opengles_texture.c
    ../Middlewares/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../Middlewares/lvgl/src/drivers/qnx/: lv_qnx.c
    ../Middlewares/lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../Middlewares/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../Middlewares/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_backend.c lv_wayland_backend_dmabuf.c lv_wayland_backend_egl.c lv_wayland_backend_g2d.c lv_wayland_backend_shm.c lv_wayland_dmabuf.c lv_wayland_keyboard.c lv_wayland_pointer.c lv_wayland_seat.c lv_wayland_touch.c lv_wayland_window.c lv_wayland_xdg_shell.c
    ../Middlewares/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../Middlewares/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../Middlewares/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/lvgl/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Middlewares/lvgl/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../Middlewares/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Middlewares/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/lvgl/src/libs/barcode/: code128.c
    ../Middlewares/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../Middlewares/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../Middlewares/lvgl/src/libs/gif/: gif.c
    ../Middlewares/lvgl/src/libs/gltf/gltf_data/: lv_gltf_model_loader.c
    ../Middlewares/lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../Middlewares/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../Middlewares/lvgl/src/libs/gltf/math/: lv_3dmath.c
    ../Middlewares/lvgl/src/libs/lodepng/: lodepng.c
    ../Middlewares/lvgl/src/libs/lz4/: lz4.c
    ../Middlewares/lvgl/src/libs/nanovg/: nanovg.c
    ../Middlewares/lvgl/src/libs/qrcode/: qrcodegen.c
    ../Middlewares/lvgl/src/libs/rle/: lv_rle.c
    ../Middlewares/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/lvgl/src/libs/tjpgd/: tjpgd.c
    ../Middlewares/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../Middlewares/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../Middlewares/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../Middlewares/lvgl/src/logging/: lv_log.c
    ../Middlewares/lvgl/src/: lv_init.c
    ../Middlewares/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/lvgl/src/others/translation/: lv_translation.c
    ../Middlewares/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/lvgl/src/themes/: lv_theme.c
    ../Middlewares/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/lvgl/src/tick/: lv_tick.c
    ../Middlewares/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/lvgl/src/widgets/barcode/: lv_barcode.c
    ../Middlewares/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/lvgl/src/widgets/gif/: lv_gif.c
    ../Middlewares/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
    ../Middlewares/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../Middlewares/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/lvgl/src/widgets/win/: lv_win.c
